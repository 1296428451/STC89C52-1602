# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: E:\Keil_v5\C51
  group Source Group 1
    ./: demo.c i2c.c lcd.c lcd.h i2c.h
